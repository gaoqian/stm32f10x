# Keil uVision project stm32f10x_boot.uvprojx, settings and files
target stm32f10x_boot (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f10x_boot
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\bsp;..\common;..\user\board;..\os\config;..\os\include;..\os\portable\ARM_CM3;..\cpu;..\cpu\CM3;..\cpu\config;..\lib_stm32\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Link\stm32f10x_boot.sct
  link misc: --keep __arm_cmd_*
  group bsp
    ../bsp/: bsp_usart.c bsp_led.c
  group user
    ../user/: main.c
  group user/app
    ../user/app/: app_cmd.c
  group user/board
    ../user/board/: board.c
  group cpu
    ../cpu/: stm32f10x_it.c system_stm32f10x.c
  group common
    ../common/: console.c command.c
  group cpu/cm3
    ../cpu/CM3/: core_cm3.c
  group cpu/startup
    ../cpu/startup/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group os
    ../os/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../os/portable/ARM_CM3/: port.c
  group os/memmang
    ../os/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
  group lib_stm32/src
    ../lib_stm32/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
